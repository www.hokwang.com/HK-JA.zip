Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-JA上下蓋.IFC
Time: 2022-01-04T06:05:54
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: HK-JA外殼
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: JA寬口上蓋01
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 外殼下蓋-修正
In: Default Storey
PredefinedType: ELEMENT; Material: 0
